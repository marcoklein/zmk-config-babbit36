## config/boards/shields/babbit36/Kconfig.defconfig
```kconfig
if BABBIT36

config ZMK_KEYBOARD_NAME
    default "babbit36"

config SPI
	default y

endif
```
